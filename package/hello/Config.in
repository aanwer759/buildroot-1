## package/hello/Config.in
```kconfig
config BR2_PACKAGE_HELLO
	bool "hello"
	help
	  Hello package to demontrate adding package directly in source tree


	  http://example.com
```
